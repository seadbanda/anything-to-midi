# IAR project Backup of ST test project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: C:\Program Files\IAR Systems\Embedded Workbench 6.0 Kickstart\arm\inc\ST; C:\projects\ST Processor work\arm\inc\STM32F10x_StdPeriph_Lib_V3.4.0\Libraries\STM32F10x_StdPeriph_Driver\inc; C:\projects\ST Processor work\arm\inc\STM32F10x_StdPeriph_Lib_V3.4.0\Libraries\STM32F10x_StdPeriph_Driver\src; C:\projects\ST Processor work\arm\inc\STM32F10x_StdPeriph_Lib_V3.4.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; C:\projects\ST Processor work\arm\inc\STM32F10x_StdPeriph_Lib_V3.4.0\Libraries\CMSIS\CM3\CoreSupport\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ST test project.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\projects\ST Processor work\arm\examples\ST\STM32F10x\IAR-STM32F103ZE-SK\Accelerometer_Demo\config\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: globaldefinitions.h main power test.c RTC.c
