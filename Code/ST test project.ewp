# IAR project ST test project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\projects\MIDI\Firmware\trunk\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport; C:\projects\MIDI\Firmware\trunk\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; C:\projects\MIDI\Firmware\trunk\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc; C:\projects\MIDI\Firmware\trunk\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\src; C:\Program Files\IAR Systems\Embedded Workbench 6.0 Kickstart\arm\inc\ST
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ST test project.bin
  ILINK.IlinkOutputFile: ST test project.out
  ILINK.IlinkIcfFile: C:\projects\MIDI\Firmware\trunk\Code\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: ControlConfig.c globaldefinitions.h Keyboard.c main.c midi.c Serial Port.c
